Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Furniture_Acoustics_Abstracta_Domo-Wall.ifc
Time: 2018-03-21T09:38:02
Author: Supplier
Organization: BIMobject
Written by: IFC Engine DLL 2017-09-06
Made in: BIMobject-Lena
Authorization: Full Scope

# IfcBuildingStorey
Elevation: 0 m

# IfcFurnishingElement: Domo Wall
ePset_BIMobjectScript - Size: 600x600; LOD: 300
ePset_BIMobject_BO - ProductName (BO_prodinfo): Domo Wall; SKU (BO_prodsku): 18290000; ManufacturName (BO_Manufac): Abstracta; BrandUrl (BO_brandurl): http://abstracta.se/; ProductFamily (BO_prodfam): Acoustic; ProductGroup (BO_prodgroup): Domo; ManufacturCountry (BO_mancont): Sweden; DesignCountry (BO_designcont): Sweden; PublishDate (BO_publisdat): 8/18/2017; EditionNumber (BO_edinum): 1; Width (BO_width): 1200; Height (BO_height): 600; Depth (BO_depth): 34; Weight (BO_weight): 0; QR (BO_boqrurl): http://bimobject.com/abstracta/product/18290000; ProductDataUrl (BO_prodaturl): bimobject.com/abstracta/product/18290000; ProductUrl (BO_producturl): http://abstracta.se/product/domo/; MaterialMain (BO_mainmat): Fabric; MaterialSecondary (BO_secmat): Wood; BimObjectMainCategory (BO_bomaincat): Furniture; BimObjectMainCategoryCode (BO_bomaincat_code): furniture; BimObjectCategory (BO_bocat): Acoustics; BimObjectCategoryCode (BO_bocat_code): furniture-acoustics; IfcClassification (BO_ifcclas): Furniture; UnspcCode (BO_unspc): 56; Uniclass14Code (BO_uniclass_1_4_code): L8211; Uniclass14Description (BO_uniclass_1_4_desc): Furniture; RegionEurope (BO_europe): AD, AL, AT, AX, BA, BE, BG, BY, CH, CY, CZ, DE, DK, EE, ES, FI, FO, FR, GB, GG, GI, GR, HR, HU, IE, IM, IS, IT, JE, LI, LT, LU, LV, MC, MD, ME, MK, MT, NL, NO, PL, PT, RO, RS, RU, SE, SI, SJ, SK, SM, UA, VA; RegionNorthAmerica (BO_northamerica): AG, AI, AW, BB, BL, BM, BQ, BS, BZ, CA, CR, CU, CW, DM, DO, GD, GL, GP, GT, HN, HT, JM, KN, KY, LC, MF, MQ, MS, MX, NI, PA, PM, PR, SV, SX, TC, TT, US, VC, VG, VI; RegionMiddleEast (BO_middleeast): AE, AF, BH, EG, IL, IQ, IR, JO, KW, LB, OM, PS, QA, SA, SY, TR, YE; RegionAsia (BO_asia): AM, AZ, BD, BN, BT, CC, CN, CX, GE, HK, ID, IN, IO, JP, KG, KH, KP, KR, KZ, LA, LK, MM, MN, MO, MV, MY, NP, PH, PK, SG, TH, TJ, TM, TW, UZ, VN; RegionOceania (BO_oceania): AS, AU, CK, FJ, FM, GU, KI, MH, MP, NC, NF, NR, NU, NZ, PF, PG, PN, PW, SB, TK, TL, TO, TV, UM, WF, WS, VU
